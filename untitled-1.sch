v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {ammeter.sym} 140 -40 0 0 {name=Vmeas savecurrent=true spice_ignore=0}
