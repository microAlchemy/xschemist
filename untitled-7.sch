v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {/Users/madelinetang/.ciel/sky130A/libs.tech/xschem/sky130_fd_pr/npn_05v5.sym} uuid=95EE5679-8DDB-485A-BE38-2797935B74F9 40 -10 0 0 {name=Q1
model=npn_05v5_w1p00l2p00 m=1
spiceprefix=X
}
