v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {/Users/madelinetang/.ciel/sky130A/libs.tech/xschem/sky130_fd_pr/res_xhigh_po.sym} uuid=C4A3A755-5123-4854-BBD7-DB415B06B672 10 -20 0 0 {name=R1
W=1
L=1
model=res_xhigh_po
spiceprefix=X
mult=1}
C {/Users/madelinetang/.ciel/sky130A/libs.tech/xschem/sky130_fd_pr/npn_05v5.sym} uuid=E16A5C35-4C94-4F90-BD3D-7CEDB7BED6FF 20 50 0 0 {name=Q1
model=npn_05v5_w1p00l2p00 m=1
spiceprefix=X
}
