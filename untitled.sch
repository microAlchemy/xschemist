v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {/Users/madelinetang/.ciel/sky130A/libs.tech/xschem/sky130_fd_pr/cap_var_hvt.sym} 50 10 0 0 {name=C1 model=cap_var_hvt W=0.5 L=0.5 VM=1 spiceprefix=X}
