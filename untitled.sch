v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {/Users/madelinetang/.ciel/sky130A/libs.tech/xschem/sky130_fd_pr/nfet_20v0.sym} 20 0 0 0 {name=M1
W=40
L=0.5
mult=1
model=nfet_20v0
spiceprefix=X
}
